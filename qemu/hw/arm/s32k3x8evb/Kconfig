## qemu/hw/arm/s32k3x8evb/Kconfig
```kconfig
#file Kconfig
config S32K3X8EVB_MCU
    bool

config S32K3X8EVB_BOARD
    bool
    select S32K3X8EVB_MCU
```
